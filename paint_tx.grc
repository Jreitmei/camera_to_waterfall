options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: paint_tx
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    start: 913e6
    step: 0.1e6
    stop: 917e6
    value: 915e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.25'
    stop: '89'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.25'
    stop: '89'
    value: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: marcy.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '4096'
    type: complex
  states: {state: disabled}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '192'
    input_size: '4096'
    tagname: ''
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: '# this module will be imported in the into your flowgraph'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '4096'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(4096)
  states: {state: disabled}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '1'
    bt709_map: '1'
    image_file: C:\Users\Administrator\Pictures\Camera Roll\captured_photo.jpg
    image_flip: '0'
    image_invert: '0'
    repeatmode: '2'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    comment: |-
      Emerson NI: 356
      Ettus Logo: 1167
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: int(10*samp_rate/2e6)
    width: '1280'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '4096'
    type: complex
    xmax: '15'
    xmin: '-15'
    ymax: '15'
    ymin: '-15'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    int_max: '-51'
    int_min: '-77'
    showports: 'True'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import cv2

      def capture_photo_from_webcam(file_path):
      	cap = cv2.VideoCapture(0)
      	
      	if not cap.isOpened():
      		print("Error: could not open camera.")
      		exit()
      	
      	desired_width = 1280
      	desired_height = 720
      	
      	cap.set(cv2.CAP_PROP_FRAME_WIDTH, desired_width)
      	cap.set(cv2.CAP_PROP_FRAME_HEIGHT, desired_height)

      	ret, frame = cap.read()

      	if ret:
      		#cv2.imshow('Captured Photo', frame)
      		cv2.imwrite(file_path, frame)
      		print(f"Photo captured and saved to {file_path}")
      		#cv2.waitKey(0)
      	else:
      		print("could not read frame.")
      	
      	cap.release()
      	print("Photo done")
      	cv2.destroyAllWindows()

      file_path = r'C:\Users\Administrator\Pictures\Camera Roll\captured_photo.jpg'
      capture_photo_from_webcam(file_path)
    section: init_before_blocks
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(frequency, 950000)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=8192,num_send_frames=128,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_freq
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: paint-cyclic
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: paint-cyclic
  states: {}

connections:
- [blocks_file_source_0, '0', paint_paint_bc_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', virtual_sink_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_throttle_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', uhd_usrp_sink_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', digital_ofdm_cyclic_prefixer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
